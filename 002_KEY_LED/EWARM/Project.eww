<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\002_KEY_LED.ewp</path>
  </project>
  <batchBuild />
</workspace>
